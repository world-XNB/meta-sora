# This is a bbappend file for the core-image-sato recipe.
# It appends the sayhello package to the image.

IMAGE_INSTALL += "sayhello"
